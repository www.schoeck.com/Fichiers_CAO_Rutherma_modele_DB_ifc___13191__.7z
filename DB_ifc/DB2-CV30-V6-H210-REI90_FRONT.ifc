Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:15:24
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV30-V6-H210-REI90
CADClick-Properties - Bestellnummer: 162165; Beschreibung: DB2-CV30-V6-H210-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV30-V6-H210-REI90; EAN: 4024342404452; Name: DB2-CV30-V6-H210-REI90
