Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T21:48:25
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV30-V8-H220-REI90
CADClick-Properties - Bestellnummer: 1023942; Beschreibung: DB2-CV30-V8-H220-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV30-V8-H220-REI90; EAN: 4024342506835; Name: DB2-CV30-V8-H220-REI90
