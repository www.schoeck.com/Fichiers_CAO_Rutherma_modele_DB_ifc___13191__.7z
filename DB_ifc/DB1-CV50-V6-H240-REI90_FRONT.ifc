Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:05:16
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB1-CV50-V6-H240-REI90
CADClick-Properties - Bestellnummer: 1039296; Beschreibung: DB1-CV50-V6-H240-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB1-CV50-V6-H240-REI90; EAN: 4024342564743; Name: DB1-CV50-V6-H240-REI90
