Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T21:50:28
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB1-CV30-V6-H230-REI90
CADClick-Properties - Bestellnummer: 1017575; Beschreibung: DB1-CV30-V6-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB1-CV30-V6-H230-REI90; EAN: 4024342494736; Name: DB1-CV30-V6-H230-REI90
