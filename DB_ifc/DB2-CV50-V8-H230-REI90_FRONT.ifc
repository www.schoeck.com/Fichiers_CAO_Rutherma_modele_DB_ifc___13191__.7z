Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:08:45
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV50-V8-H230-REI90
CADClick-Properties - Bestellnummer: 176345; Beschreibung: DB2-CV50-V8-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV50-V8-H230-REI90; EAN: 4024342393725; Name: DB2-CV50-V8-H230-REI90
