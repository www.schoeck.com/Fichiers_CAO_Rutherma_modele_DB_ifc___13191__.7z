Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:16:59
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV50-V6-H170-R120
CADClick-Properties - Bestellnummer: 1029403; Beschreibung: DB3-CV50-V6-H170-R120; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV50-V6-H170-R120; EAN: 4024342533763; Name: DB3-CV50-V6-H170-R120
