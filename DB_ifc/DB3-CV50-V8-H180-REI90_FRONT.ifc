Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:08:45
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV50-V8-H180-REI90
CADClick-Properties - Bestellnummer: 1086981; Beschreibung: DB3-CV50-V8-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV50-V8-H180-REI90; EAN: 4024342819225; Name: DB3-CV50-V8-H180-REI90
