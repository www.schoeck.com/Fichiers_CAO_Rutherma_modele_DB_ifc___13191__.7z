Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:39:52
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV30-V8-H230-REI90
CADClick-Properties - Bestellnummer: 1124906; Beschreibung: DB2-CV30-V8-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV30-V8-H230-REI90; EAN: 0; Name: DB2-CV30-V8-H230-REI90
