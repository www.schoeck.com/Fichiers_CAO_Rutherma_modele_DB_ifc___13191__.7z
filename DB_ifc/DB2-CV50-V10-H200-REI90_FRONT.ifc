Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:13:36
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV50-V10-H200-REI90
CADClick-Properties - Bestellnummer: 1055379; Beschreibung: DB2-CV50-V10-H200-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV50-V10-H200-REI90; EAN: 4024342660360; Name: DB2-CV50-V10-H200-REI90
