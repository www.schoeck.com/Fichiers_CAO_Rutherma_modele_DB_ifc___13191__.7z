Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:14:26
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV50-V6-H190-REI90
CADClick-Properties - Bestellnummer: 1029609; Beschreibung: DB3-CV50-V6-H190-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV50-V6-H190-REI90; EAN: 4024342534975; Name: DB3-CV50-V6-H190-REI90
