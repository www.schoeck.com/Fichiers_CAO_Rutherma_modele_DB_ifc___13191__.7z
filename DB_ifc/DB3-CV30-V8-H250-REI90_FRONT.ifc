Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T21:56:44
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV30-V8-H250-REI90
CADClick-Properties - Bestellnummer: 1029153; Beschreibung: DB3-CV30-V8-H250-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV30-V8-H250-REI90; EAN: 4024342532230; Name: DB3-CV30-V8-H250-REI90
