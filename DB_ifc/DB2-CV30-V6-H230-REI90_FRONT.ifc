Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:09:50
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV30-V6-H230-REI90
CADClick-Properties - Bestellnummer: 165864; Beschreibung: DB2-CV30-V6-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV30-V6-H230-REI90; EAN: 4024342401178; Name: DB2-CV30-V6-H230-REI90
