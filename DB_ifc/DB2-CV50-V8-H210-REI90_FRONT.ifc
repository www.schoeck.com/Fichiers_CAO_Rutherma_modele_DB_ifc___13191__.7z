Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:33:23
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV50-V8-H210-REI90
CADClick-Properties - Bestellnummer: 1124892; Beschreibung: DB2-CV50-V8-H210-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV50-V8-H210-REI90; EAN: 0; Name: DB2-CV50-V8-H210-REI90
