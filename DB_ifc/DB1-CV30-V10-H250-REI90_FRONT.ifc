Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:27:15
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB1-CV30-V10-H250-REI90
CADClick-Properties - Bestellnummer: 1124876; Beschreibung: DB1-CV30-V10-H250-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB1-CV30-V10-H250-REI90; EAN: 0; Name: DB1-CV30-V10-H250-REI90
