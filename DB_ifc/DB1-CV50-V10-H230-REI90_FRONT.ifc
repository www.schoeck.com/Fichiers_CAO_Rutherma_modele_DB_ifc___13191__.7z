Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:21:23
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB1-CV50-V10-H230-REI90
CADClick-Properties - Bestellnummer: 1124858; Beschreibung: DB1-CV50-V10-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB1-CV50-V10-H230-REI90; EAN: 0; Name: DB1-CV50-V10-H230-REI90
