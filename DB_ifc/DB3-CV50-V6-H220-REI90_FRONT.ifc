Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:23:49
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV50-V6-H220-REI90
CADClick-Properties - Bestellnummer: 193080; Beschreibung: DB3-CV50-V6-H220-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV50-V6-H220-REI90; EAN: 4024342329007; Name: DB3-CV50-V6-H220-REI90
