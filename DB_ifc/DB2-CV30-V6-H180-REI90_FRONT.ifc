Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:16:00
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV30-V6-H180-REI90
CADClick-Properties - Bestellnummer: 138147; Beschreibung: DB2-CV30-V6-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV30-V6-H180-REI90; EAN: 4024342409945; Name: DB2-CV30-V6-H180-REI90
