Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:33:51
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV50-V10-H180-REI90
CADClick-Properties - Bestellnummer: 1124911; Beschreibung: DB3-CV50-V10-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV50-V10-H180-REI90; EAN: 0; Name: DB3-CV50-V10-H180-REI90
