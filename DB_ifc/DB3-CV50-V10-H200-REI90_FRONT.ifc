Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:31:27
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV50-V10-H200-REI90
CADClick-Properties - Bestellnummer: 1124913; Beschreibung: DB3-CV50-V10-H200-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV50-V10-H200-REI90; EAN: 0; Name: DB3-CV50-V10-H200-REI90
