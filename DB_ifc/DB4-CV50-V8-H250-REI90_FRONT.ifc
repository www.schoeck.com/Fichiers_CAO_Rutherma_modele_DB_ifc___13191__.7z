Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:13:09
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB4-CV50-V8-H250-REI90
CADClick-Properties - Bestellnummer: 1029630; Beschreibung: DB4-CV50-V8-H250-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB4-CV50-V8-H250-REI90; EAN: 4024342535071; Name: DB4-CV50-V8-H250-REI90
