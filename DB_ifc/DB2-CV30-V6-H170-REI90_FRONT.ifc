Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:03:25
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB2-CV30-V6-H170-REI90
CADClick-Properties - Bestellnummer: 1040333; Beschreibung: DB2-CV30-V6-H170-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB2-CV30-V6-H170-REI90; EAN: 4024342566372; Name: DB2-CV30-V6-H170-REI90
