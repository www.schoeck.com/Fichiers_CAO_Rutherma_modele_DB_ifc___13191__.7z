Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:06:31
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB4-CV50-V8-H200-REI90
CADClick-Properties - Bestellnummer: 186183; Beschreibung: DB4-CV50-V8-H200-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB4-CV50-V8-H200-REI90; EAN: 4024342362714; Name: DB4-CV50-V8-H200-REI90
