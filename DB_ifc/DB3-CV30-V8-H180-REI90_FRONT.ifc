Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T23:07:39
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB3-CV30-V8-H180-REI90
CADClick-Properties - Bestellnummer: 182819; Beschreibung: DB3-CV30-V8-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB3-CV30-V8-H180-REI90; EAN: 4024342369126; Name: DB3-CV30-V8-H180-REI90
