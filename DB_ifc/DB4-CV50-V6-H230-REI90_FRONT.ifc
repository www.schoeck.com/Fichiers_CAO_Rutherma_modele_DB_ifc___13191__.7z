Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-25T22:05:43
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, DB4-CV50-V6-H230-REI90
CADClick-Properties - Bestellnummer: 1025130; Beschreibung: DB4-CV50-V6-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: DB4-CV50-V6-H230-REI90; EAN: 4024342512935; Name: DB4-CV50-V6-H230-REI90
